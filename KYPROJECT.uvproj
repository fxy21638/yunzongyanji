# Keil uVision project KYPROJECT.uvproj, settings and files
target stc32g144k246_100pin (MCS-251)
  device: AI8052U-32Bit Series AI
  cpu: IRAM(0-0x3FFF) XRAM(0x10000-0x2FFFF) IROM(0xFC0000-0xFFFFFF) CLOCK(35000000)
  output: KYPROJECT +hex
  link misc: REMOVEUNUSED
  group code
    ./code/: key.c key.h motor.c motor.h encoder.c encoder.h servo.c servo.h icm.c icm.h vision.c vision.h vision_track.c vision_track.h vision_master.c vision_master.h pid.c pid.h trail.c trail.h
  group main
    ./main/: isr.c main.c main.h
  group common
    ./library/common/: ky_font.c ky_font.h ky_headfile.h ky_math.c ky_math.h ky_ringbuffer.c ky_ringbuffer.h ky_utils.c ky_utils.h ky_key.c ky_key.h ky_assistant.c ky_assistant.h ky_typedef.h ky_assert.c ky_assert.h
  group devices
    ./library/devices/: ky_ips.c ky_ips.h ky_mt9v034.c ky_mt9v034.h ky_mt9v034_config.c ky_mt9v034_config.h ky_icm45686.c ky_icm45686.h ky_imu_base.c ky_imu_base.h ky_lsm6dsr.c ky_lsm6dsr.h ky_wireless_com.c ky_wireless_com.h ky_gnss.c ky_gnss.h ky_wifi.c ky_wifi.h ky_icm42686.c ky_icm42686.h
  group drivers
    ./library/drivers/: ky_adc.c ky_adc.h ky_delay.c ky_delay.h ky_encoder.c ky_encoder.h ky_gpio.c ky_gpio.h ky_pwm.c ky_pwm.h ky_spi.c ky_spi.h ky_system_clock.c ky_system_clock.h ky_timer.c ky_timer.h ky_uart.c ky_uart.h ky_usb_cdc.c ky_usb_cdc.h ky_soft_i2c.c ky_soft_i2c.h
  group core
    ./library/core/: config.h def.h START251.A51 stc32g144k246.h stc32g144k246_def.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h STC32_DSP32_HUGE.LIB
  group doc
    ./doc/: CHANGELOG.md
